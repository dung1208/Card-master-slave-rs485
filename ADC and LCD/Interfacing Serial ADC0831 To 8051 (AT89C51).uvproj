# Keil uVision project Interfacing Serial ADC0831 To 8051 (AT89C51).uvproj, settings and files
target Target 1 (MCS-51)
  device: 89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: Interfacing Serial ADC0831 To 8051 (AT89C51) +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Main.c ADC0831.c LCD4Bit.c
